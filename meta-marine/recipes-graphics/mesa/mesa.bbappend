INSANE_SKIP:${PN}-src = "buildpaths"
INSANE_SKIP:${PN}-vulkan-drivers = "buildpaths"

